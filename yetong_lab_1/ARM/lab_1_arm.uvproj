# Keil uVision project lab_1_arm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: lab_1_arm +hex
  c flags: Optim=1
  group Source Group 1
    ./: Lab_1_ASM_Keil_ARM7.s
