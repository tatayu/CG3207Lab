# Keil uVision project lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: lab1 +hex
  c flags: Optim=1
  group Source Group 1
    C:/Keil/Lab/: Sample_ASM_Keil_ARM7.s
